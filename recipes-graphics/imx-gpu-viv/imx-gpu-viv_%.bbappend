INHIBIT_PACKAGE_STRIP = "0"
INSANE_SKIP_${PN} = "already-stripped"
