RDEPENDS_${PN} += " \
    libegl-mx6 \
    libegl-mx6-dev \
    libgles2-mx6 \
    libgles2-mx6-dev \
"
