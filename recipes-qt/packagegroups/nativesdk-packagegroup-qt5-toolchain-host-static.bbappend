RDEPENDS_${PN} += " \
    nativesdk-make-initfs-dev \
"
