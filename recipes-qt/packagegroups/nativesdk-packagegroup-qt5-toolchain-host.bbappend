RDEPENDS_${PN} += " \
    nativesdk-make-ui-dev \
"
